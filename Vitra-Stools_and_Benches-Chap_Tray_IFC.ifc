Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-12-22T09:23:41
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Dec 22 09:23:41 2021 * Host: DESKTOP-RBR1KM2 * Database: C:\Users\andre\AppData\Local\Temp\{CDB2F746-1D4E-4247-82E3-93A264DF8C90}\ifc * Database version: 5507 * Database creation date: Wed Dec 22 09:23:40 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Dec 22 09:23:40 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Dec 22 09:23:40 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcFurnishingElement: Chap Tray, Vitra-Stools_and_Benches-Chap_Tray:Chap Tray:4228
In: Level 1
Type - Material: Sea Blue
Type - General - Author: BIMStone; BIMObjectName: Vitra-Stools_and_Benches-Chap_Tray; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Domestic chairs; NBSReference: 45-35-20/365; ProductInformation: Chap looks familiar at first sight: its kinship with small four-legged stools or side tables is immediately evident. The quality of such designs lies in their generic appearance and universal applications, which is why they are never restricted to a specific function. Chap is particularly adaptable and flexible: in a home setting it serves as a practical footstool, as a side table or as a seating option when there are extra guests. And because it is lightweight and stackable, Chap can be taken along to workshops, meetings and other types of gatherings in the office and stored away again just as quickly. Its stable leg construction provides a sturdy support for the high-lipped Chap Tray. One or several of these containers can be positioned and stacked below the seat of the stool for storing the user's phone, cables, papers and other utensils.; Revision: n/a; Uniclass2: Pr_40_50_12_83; Uniclass2015Description: Stools; Uniclass2015Reference: Pr_40_50_12_85; Version: 1; VersionDate: 20/10/2021
Type - Identity Data - Cost: 0; Description: Chap looks familiar at first sight: its kinship with small four-legged stools or side tables is immediately evident. The quality of such designs lies in their generic appearance and universal applications, which is why they are never restricted to a specific function. Chap is particularly adaptable and flexible: in a home setting it serves as a practical footstool, as a side table or as a seating option when there are extra guests. And because it is lightweight and stackable, Chap can be taken along to workshops, meetings and other types of gatherings in the office and stored away again just as quickly. Its stable leg construction provides a sturdy support for the high-lipped Chap Tray. One or several of these containers can be positioned and stacked below the seat of the stool for storing the user's phone, cables, papers and other utensils.; Design: Konstantin Grcic; Manufacturer: Vitra; Model: Chap Tray; OmniClass Number: 23.40.20.14.14.11; OmniClass Title: Chairs; Type Name: Chap Tray; URL: https://www.vitra.com/en-un/product/chap
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Stools_and_Benches-Chap_Tray; Features: Material: post-industrial recycled polyamide, 100% recyclable.; Finish: Chap and Chap Tray are made of plastic from recycled industrial waste and are 100% recyclable themselves. Both products are available in a selection of colours.; Grade: n/a; Material: Polyamide; ModelNumber: n/a; ModelReference: n/a; Name: Chap_Tray; ReplacementCost: n/a; Shape: Sculptured; Size: 415x200x65 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: n/a; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.122975 m2; Volume: 0.005395 m3
Materials and Finishes - Colour: Sea Blue
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Stools_and_Benches-Chap_Tray: Chap Tray; Family and Type: Vitra-Stools_and_Benches-Chap_Tray: Chap Tray; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Stools_and_Benches-Chap_Tray: Chap Tray; Type Id: Vitra-Stools_and_Benches-Chap_Tray: Chap Tray; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
